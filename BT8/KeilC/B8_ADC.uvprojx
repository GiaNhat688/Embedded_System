# Keil uVision project B8_ADC.uvprojx, settings and files
target Target 1 (6140000::V6.14::.\ARM\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: B7_ADC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group New Group
    ./: main.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
